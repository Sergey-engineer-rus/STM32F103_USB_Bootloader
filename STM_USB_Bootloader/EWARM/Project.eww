<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\STM_USB_Bootloader.ewp</path>
  </project>
  <batchBuild />
</workspace>
